Commit message: urdf建模

File: src/simulation_learning/models/urdf/mbot_with_laser_camera.urdf (robot description, URDF)
Before this commit: robot mbot, 8 links, 7 joints
Links:
- removed link floor_link
Joints:
- removed joint base_joint
